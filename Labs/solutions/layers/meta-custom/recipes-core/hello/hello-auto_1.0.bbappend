FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-change-from-meta-custom.patch"
