FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-reduced-hash-memory.patch"
