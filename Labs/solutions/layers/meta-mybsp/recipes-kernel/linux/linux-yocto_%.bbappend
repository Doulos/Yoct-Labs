COMPATIBLE_MACHINE:myqemu = "myqemu"

# Creates mapping between machine name and kernel defconfig name
KMACHINE:myqemu = "qemuarm64"
