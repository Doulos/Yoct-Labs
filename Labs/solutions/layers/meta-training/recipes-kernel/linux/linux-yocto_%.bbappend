FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://bluetooth.cfg"
