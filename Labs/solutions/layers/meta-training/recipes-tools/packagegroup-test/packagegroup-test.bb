SUMMARY = "Test package groups"

inherit packagegroup

RDEPENDS:${PN} = "\
xauth \
xhost \
"
