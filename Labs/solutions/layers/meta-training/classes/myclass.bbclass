myclass_do_taskA () {
    echo "hello world from my class"
}

EXPORT_FUNCTIONS do_taskA
